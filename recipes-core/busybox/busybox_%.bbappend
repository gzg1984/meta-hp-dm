require hp-dm.inc

FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"


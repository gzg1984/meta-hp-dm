FILESEXTRAPATHS_prepend := "${THISDIR}/glibc:"

SRC_URI += " file://0001-write-to-file.patch \
"

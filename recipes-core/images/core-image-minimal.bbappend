IMAGE_INSTALL += "busybox-hp-dm-private"
